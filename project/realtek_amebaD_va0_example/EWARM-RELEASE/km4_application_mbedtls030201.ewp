# IAR project km4_application_mbedtls030201.ewp, settings and files
configuration is (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: CONFIG_PLATFORM_8721D; __FPU_PRESENT; CONFIG_USE_MBEDTLS_ROM_ALG; CONFIG_FUNCION_O0_OPTIMIZE; DM_ODM_SUPPORT_TYPE=32
  ICCARM.IExtraOptions: --no_path_in_file_macros; --cmse
  ICCARM.CCIncludePath2: ..\..\..\component\os\; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\include\; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_HP\non_secure; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_HP\secure; ..\..\..\component\soc\realtek\amebad\cmsis\; ..\..\..\component\soc\realtek\amebad\cmsis\device; ..\..\..\component\soc\realtek\amebad\fwlib\include; ..\..\..\component\soc\realtek\amebad\fwlib\rom_map_hp; ..\..\..\component\soc\realtek\amebad\app\monitor\include; ..\..\..\component\soc\realtek\amebad\app\xmodem; ..\..\..\component\soc\realtek\amebad\swlib\include; ..\..\..\component\soc\realtek\amebad\swlib\string; ..\..\..\component\soc\realtek\amebad\misc; ..\..\..\component\soc\realtek\amebad\swlib\os_dep\include\; ..\..\..\component\soc\realtek\amebad\swlib\os_dep\..\; ..\..\..\component\soc\realtek\amebad\swlib\string; ..\inc\inc_hp; ..\..\..\component\common\api; ..\..\..\component\common\api\platform; ..\..\..\component\common\api\wifi; ..\..\..\component\common\api\network; ..\..\..\component\common\api\network\include; ..\..\..\component\common\audio; ..\..\..\component\common\test; ..\..\..\component\common\example; ..\..\..\component\common\utilities; ..\..\..\component\common\drivers\si; ..\..\..\component\common\audio\haac; ..\..\..\component\common\audio\hmp3; ..\..\..\component\common\audio\fdk-aac; ..\..\..\component\common\audio\libav; ..\..\..\component\common\audio\fdk-aac\libSYS\include; ..\..\..\component\common\drivers\wlan\realtek\include; ..\..\..\component\common\drivers\wlan\realtek\src\hci; ..\..\..\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\component\common\drivers\wlan\realtek\src\hal; ..\..\..\component\common\drivers\wlan\realtek\src\hal\phydm; ..\..\..\component\common\drivers\wlan\realtek\src\hal\rtl8721d; ..\..\..\component\common\drivers\wlan\realtek\src\hal\rtl8721d\little_driver\include; ..\..\..\component\common\drivers\wlan\realtek\wlan_ram_map\rom; ..\..\..\component\common\network; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include\lwip; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include\netif; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek\freertos; ..\..\..\component\common\api; ..\..\..\component\common\api\at_cmd; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\component\os\os_dep\include\; ..\..\..\component\common\drivers\inic\rtl8721d; ..\..\..\component\common\network\ssl\polarssl-1.3.8\include; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\common\network\ssl\mbedtls-3.2.1\include; ..\..\..\component\common\network\ssl\mbedtls-3.2.1\library; ..\..\..\component\common\network\ssl\mbedtls_ram_map\rom; ..\..\..\component\common\mbed\targets\hal\rtl8721d\; ..\..\..\component\common\mbed\targets\hal\rtl8721d\include; ..\..\..\component\common\mbed\api; ..\..\..\component\common\mbed\hal; ..\..\..\component\common\mbed\hal_ext; ..\..\..\component\common\application\baidu\libduer-device\external\mbedtls-port; ..\..\..\component\common\application\apple\WACServer\External\Curve25519; ..\..\..\component\common\application\apple\WACServer\External\GladmanAES; ..\..\..\component\common\application\apple\homekit\crypto\chacha; ..\..\..\component\common\application\apple\homekit\crypto\poly1305; ..\..\..\component\common\application\apple\homekit\crypto\ed25519; ..\..\..\component\common\application\apple\homekit\crypto\ed25519\core; ..\..\..\component\common\application\apple\homekit\crypto\sha512; ..\..\..\component\common\file_system\fatfs\r0.10c\include; ..\..\..\component\common\file_system\fatfs; ..\..\..\component\common\file_system\ftl; ..\..\..\component\common\application\baidu\libduer-device\framework\core; ..\..\..\component\common\application\baidu\libduer-device\framework\include; ..\..\..\component\common\application\baidu\duerapp\include; $TOOLKIT_DIR$\inc\c; ..\..\..\component\common\network\coap\include; ..\..\..\component\common\drivers\sdio\realtek\sdio_host\inc; ..\..\..\component\common\drivers\wlan\realtek\src\core\option; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src\crypto; ..\..\..\component\common\application\amazon\amazon-freertos\lib\include\private; ..\src\src_hp; ..\..\..\component\common\drivers\ir\protocol; ..\..\..\component\common\ui\emwin\emWinLibrary\include; ..\..\..\component\common\ui\emwin\Sample\rtl8721d\Config; ..\..\..\component\common\ui\emwin\Sample\rtl8721d\hal; ..\..\..\component\common\ui\emwin\Third_Party\truetype; ..\..\..\component\common\drivers\ir\protocol; ..\..\..\component\common\network\libcoap\include; ..\..\..\component\common\bluetooth\realtek\sdk; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebad\lib; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebad\src; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebad\src\hci; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebad\src\vendor_cmd; ..\..\..\component\common\bluetooth\realtek\sdk\board\common\inc; ..\..\..\component\common\bluetooth\realtek\sdk\example\ble_central; ..\..\..\component\common\bluetooth\realtek\sdk\example\ble_peripheral; ..\..\..\component\common\bluetooth\realtek\sdk\example\ble_scatternet; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_airsync_config; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_beacon; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_breeze; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_config; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_tag_scanner; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_ancs; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_distance_detector; ..\..\..\component\common\bluetooth\realtek\sdk\inc; ..\..\..\component\common\bluetooth\realtek\sdk\inc\app; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\gap; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\client; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\server; ..\..\..\component\common\bluetooth\realtek\sdk\inc\os; ..\..\..\component\common\bluetooth\realtek\sdk\inc\platform; ..\..\..\component\common\bluetooth\realtek\sdk\inc\stack; ..\..\..\component\common\bluetooth\realtek\sdk\src\mcu\module\data_uart_cmd; ..\..\..\component\common\application\airsync\1.0.4; ..\..\..\component\common\application\breeze\api; ..\..\..\component\common\application\breeze\core\include; ..\..\..\component\common\application\breeze\include; ..\..\..\component\common\application\breeze\ref-impl; ..\..\..\component\common\network\ssl\mbedtls-3.2.1\include\mbedtls; ..\..\..\component\common\network\ssl\mbedtls-3.2.1\library; ..\..\..\component\common\file_system\dct; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\cmd; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\common; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\gap; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\inc; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\inc\amebad; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\model; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\model\realtek; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\platform; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\profile; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\provisioner; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\device; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_device_rtk_demo; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_provisioner_rtk_demo; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_provisioner_rtk_demo\inc; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\api; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\api\device; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\api\provisioner; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_multiple_profile\device_multiple_profile; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_multiple_profile\provisioner_multiple_profile; ..\..\..\component\common\media\mmfv2; ..\..\..\component\common\media\rtp_codec
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..\..\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_HP\non_secure; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_HP\secure; ..\inc\inc_hp
  OBJCOPY.OOCOutputFile: km4_application.srec
  prebuild: CSCRIPT  "..\..\..\component\soc\realtek\amebad\misc\iar_utility\common\rtl8721d_prebuild.vbs" "$PROJ_DIR$" "..\inc\inc_hp"
  postbuild: CSCRIPT  "..\..\..\component\soc\realtek\amebad\misc\iar_utility\common\rtl8721dhp_postbuild_img2.vbs" "$TARGET_DIR$" "$PROJ_DIR$" "$TOOLKIT_DIR$" "normal"
  ILINK.IlinkOutputFile: km4_application.axf
  ILINK.IlinkIcfFile: rtl8721dhp_image2_is.icf
  ILINK.IlinkExtraOptions: --redirect aesccmp_construct_mic_iv=aesccmp_construct_mic_iv_ram; --redirect aesccmp_construct_mic_header1=aesccmp_construct_mic_header1_ram; --redirect aesccmp_construct_ctr_preload=aesccmp_construct_ctr_preload_ram; --redirect rom_psk_CalcGTK=ram_patch_rom_psk_CalcGTK; --redirect rom_psk_CalcPTK=ram_patch_rom_psk_CalcPTK; --redirect aes_80211_encrypt=ram_patch_aes_80211_encrypt; --redirect aes_80211_decrypt=ram_patch_aes_80211_decrypt
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration is (mp) (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CONFIG_PLATFORM_8721D; __FPU_PRESENT; CONFIG_USE_MBEDTLS_ROM_ALG; CONFIG_FUNCION_O0_OPTIMIZE; DM_ODM_SUPPORT_TYPE=32; CONFIG_MP_INCLUDED; CONFIG_BT_MP
  ICCARM.CCIncludePath2: ..\..\..\component\os\; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\include\; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_HP\non_secure; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_HP\secure; ..\..\..\component\soc\realtek\amebad\cmsis\; ..\..\..\component\soc\realtek\amebad\cmsis\device; ..\..\..\component\soc\realtek\amebad\fwlib\include; ..\..\..\component\soc\realtek\amebad\fwlib\rom_map_hp; ..\..\..\component\soc\realtek\amebad\app\monitor\include; ..\..\..\component\soc\realtek\amebad\app\xmodem; ..\..\..\component\soc\realtek\amebad\swlib\include; ..\..\..\component\soc\realtek\amebad\swlib\string; ..\..\..\component\soc\realtek\amebad\misc; ..\..\..\component\soc\realtek\amebad\swlib\os_dep\include\; ..\..\..\component\soc\realtek\amebad\swlib\os_dep\..\; ..\..\..\component\soc\realtek\amebad\swlib\string; ..\inc\inc_hp; ..\..\..\component\common\api; ..\..\..\component\common\api\platform; ..\..\..\component\common\api\wifi; ..\..\..\component\common\api\network; ..\..\..\component\common\api\network\include; ..\..\..\component\common\audio; ..\..\..\component\common\test; ..\..\..\component\common\example; ..\..\..\component\common\utilities; ..\..\..\component\common\drivers\si; ..\..\..\component\common\audio\haac; ..\..\..\component\common\audio\hmp3; ..\..\..\component\common\audio\fdk-aac; ..\..\..\component\common\audio\libav; ..\..\..\component\common\audio\fdk-aac\libSYS\include; ..\..\..\component\common\drivers\wlan\realtek\include; ..\..\..\component\common\drivers\wlan\realtek\src\hci; ..\..\..\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\component\common\drivers\wlan\realtek\src\hal; ..\..\..\component\common\drivers\wlan\realtek\src\hal\phydm; ..\..\..\component\common\drivers\wlan\realtek\src\hal\rtl8721d; ..\..\..\component\common\drivers\wlan\realtek\src\hal\rtl8721d\little_driver\include; ..\..\..\component\common\drivers\wlan\realtek\wlan_ram_map\rom; ..\..\..\component\common\network; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include\lwip; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include\netif; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek\freertos; ..\..\..\component\common\api; ..\..\..\component\common\api\at_cmd; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\component\os\os_dep\include\; ..\..\..\component\common\drivers\inic\rtl8721d; ..\..\..\component\common\network\ssl\polarssl-1.3.8\include; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\common\network\ssl\mbedtls-3.2.1\include; ..\..\..\component\common\network\ssl\mbedtls-3.2.1\library; ..\..\..\component\common\network\ssl\mbedtls_ram_map\rom; ..\..\..\component\common\mbed\targets\hal\rtl8721d\; ..\..\..\component\common\mbed\targets\hal\rtl8721d\include; ..\..\..\component\common\mbed\api; ..\..\..\component\common\mbed\hal; ..\..\..\component\common\mbed\hal_ext; ..\..\..\component\common\application\baidu\libduer-device\external\mbedtls-port; ..\..\..\component\common\application\apple\WACServer\External\Curve25519; ..\..\..\component\common\application\apple\WACServer\External\GladmanAES; ..\..\..\component\common\application\apple\homekit\crypto\chacha; ..\..\..\component\common\application\apple\homekit\crypto\poly1305; ..\..\..\component\common\application\apple\homekit\crypto\ed25519; ..\..\..\component\common\application\apple\homekit\crypto\ed25519\core; ..\..\..\component\common\application\apple\homekit\crypto\sha512; ..\..\..\component\common\file_system\fatfs\r0.10c\include; ..\..\..\component\common\file_system\fatfs; ..\..\..\component\common\file_system\ftl; ..\..\..\component\common\application\baidu\libduer-device\framework\core; ..\..\..\component\common\application\baidu\libduer-device\framework\include; ..\..\..\component\common\application\baidu\duerapp\include; $TOOLKIT_DIR$\inc\c; ..\..\..\component\common\network\coap\include; ..\..\..\component\common\drivers\sdio\realtek\sdio_host\inc; ..\..\..\component\common\drivers\wlan\realtek\src\core\option; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src\crypto; ..\..\..\component\common\application\amazon\amazon-freertos\lib\include\private; ..\..\..\component\common\ui\emwin\emWinLibrary\include; ..\..\..\component\common\ui\emwin\Sample\rtl8721d\Config; ..\..\..\component\common\ui\emwin\Sample\rtl8721d\hal; ..\..\..\component\common\ui\emwin\Third_Party\truetype; ..\..\..\component\common\network\libcoap\include; ..\..\..\component\common\bluetooth\realtek\sdk; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebad\lib; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebad\src; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebad\src\hci; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebad\src\vendor_cmd; ..\..\..\component\common\bluetooth\realtek\sdk\board\common\inc; ..\..\..\component\common\bluetooth\realtek\sdk\example\ble_central; ..\..\..\component\common\bluetooth\realtek\sdk\example\ble_peripheral; ..\..\..\component\common\bluetooth\realtek\sdk\example\ble_scatternet; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_airsync_config; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_beacon; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_breeze; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_config; ..\..\..\component\common\bluetooth\realtek\sdk\inc; ..\..\..\component\common\bluetooth\realtek\sdk\inc\app; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\gap; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\client; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\server; ..\..\..\component\common\bluetooth\realtek\sdk\inc\os; ..\..\..\component\common\bluetooth\realtek\sdk\inc\platform; ..\..\..\component\common\bluetooth\realtek\sdk\inc\stack; ..\..\..\component\common\bluetooth\realtek\sdk\src\mcu\module\data_uart_cmd; ..\..\..\component\common\application\airsync\1.0.4; ..\..\..\component\common\application\breeze\api; ..\..\..\component\common\application\breeze\core\include; ..\..\..\component\common\application\breeze\include; ..\..\..\component\common\application\breeze\library; ..\..\..\component\common\application\breeze\ref-impl; ..\..\..\component\common\network\ssl\mbedtls-3.2.1\include\mbedtls; ..\..\..\component\common\file_system\dct; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\api; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\api\device; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\api\provisioner; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\device; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\cmd; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\common; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\gap; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\inc; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\inc\amebaz2; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\model; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\model\realtek; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\platform; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\profile; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\provisioner; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_device_rtk_demo; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_multiple_profile\device_multiple_profile; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_multiple_profile\provisioner_multiple_profile; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_provisioner_rtk_demo; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_provisioner_rtk_demo\inc; ..\..\..\component\common\media\mmfv2; ..\..\..\component\common\media\rtp_codec
  AARM.ADefines: as above
  postbuild: CSCRIPT  "..\..\..\component\soc\realtek\amebad\misc\iar_utility\common\rtl8721dhp_postbuild_img2.vbs" "$TARGET_DIR$" "$PROJ_DIR$" "$TOOLKIT_DIR$" "mp"
configuration tz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CONFIG_PLATFORM_8721D; __FPU_PRESENT; CONFIG_USE_MBEDTLS_ROM_ALG; CONFIG_FUNCION_O0_OPTIMIZE; DM_ODM_SUPPORT_TYPE=32; CONFIG_TRUSTZONE_EN=1; CONFIG_BUILD_NONSECURE=1
  ICCARM.CCIncludePath2: ..\..\..\component\os\; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\include\; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_HP\non_secure; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_HP\secure; ..\..\..\component\soc\realtek\amebad\cmsis\; ..\..\..\component\soc\realtek\amebad\cmsis\device; ..\..\..\component\soc\realtek\amebad\fwlib\include; ..\..\..\component\soc\realtek\amebad\fwlib\rom_map_hp; ..\..\..\component\soc\realtek\amebad\app\monitor\include; ..\..\..\component\soc\realtek\amebad\app\xmodem; ..\..\..\component\soc\realtek\amebad\swlib\include; ..\..\..\component\soc\realtek\amebad\swlib\string; ..\..\..\component\soc\realtek\amebad\misc; ..\..\..\component\soc\realtek\amebad\swlib\os_dep\include\; ..\..\..\component\soc\realtek\amebad\swlib\os_dep\..\; ..\..\..\component\soc\realtek\amebad\swlib\string; ..\inc\inc_hp; ..\..\..\component\common\api; ..\..\..\component\common\api\platform; ..\..\..\component\common\api\wifi; ..\..\..\component\common\api\network; ..\..\..\component\common\api\network\include; ..\..\..\component\common\audio; ..\..\..\component\common\test; ..\..\..\component\common\example; ..\..\..\component\common\utilities; ..\..\..\component\common\drivers\si; ..\..\..\component\common\audio\haac; ..\..\..\component\common\audio\hmp3; ..\..\..\component\common\audio\fdk-aac; ..\..\..\component\common\audio\libav; ..\..\..\component\common\audio\fdk-aac\libSYS\include; ..\..\..\component\common\drivers\wlan\realtek\include; ..\..\..\component\common\drivers\wlan\realtek\src\hci; ..\..\..\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\component\common\drivers\wlan\realtek\src\hal; ..\..\..\component\common\drivers\wlan\realtek\src\hal\phydm; ..\..\..\component\common\drivers\wlan\realtek\src\hal\rtl8721d; ..\..\..\component\common\drivers\wlan\realtek\src\hal\rtl8721d\little_driver\include; ..\..\..\component\common\drivers\wlan\realtek\wlan_ram_map\rom; ..\..\..\component\common\network; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include\lwip; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include\netif; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek\freertos; ..\..\..\component\common\api; ..\..\..\component\common\api\at_cmd; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\component\os\os_dep\include\; ..\..\..\component\common\drivers\inic\rtl8721d; ..\..\..\component\common\network\ssl\polarssl-1.3.8\include; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\common\network\ssl\mbedtls-3.2.1\include; ..\..\..\component\common\network\ssl\mbedtls-3.2.1\library; ..\..\..\component\common\network\ssl\mbedtls_ram_map\rom; ..\..\..\component\common\mbed\targets\hal\rtl8721d\; ..\..\..\component\common\mbed\targets\hal\rtl8721d\include; ..\..\..\component\common\mbed\api; ..\..\..\component\common\mbed\hal; ..\..\..\component\common\mbed\hal_ext; ..\..\..\component\common\application\baidu\libduer-device\external\mbedtls-port; ..\..\..\component\common\application\apple\WACServer\External\Curve25519; ..\..\..\component\common\application\apple\WACServer\External\GladmanAES; ..\..\..\component\common\application\apple\homekit\crypto\chacha; ..\..\..\component\common\application\apple\homekit\crypto\poly1305; ..\..\..\component\common\application\apple\homekit\crypto\ed25519; ..\..\..\component\common\application\apple\homekit\crypto\ed25519\core; ..\..\..\component\common\application\apple\homekit\crypto\sha512; ..\..\..\component\common\file_system\fatfs\r0.10c\include; ..\..\..\component\common\file_system\fatfs; ..\..\..\component\common\file_system\ftl; ..\..\..\component\common\application\baidu\libduer-device\framework\core; ..\..\..\component\common\application\baidu\libduer-device\framework\include; ..\..\..\component\common\application\baidu\duerapp\include; $TOOLKIT_DIR$\inc\c; ..\..\..\component\common\network\coap\include; ..\..\..\component\common\drivers\sdio\realtek\sdio_host\inc; ..\..\..\component\common\drivers\wlan\realtek\src\core\option; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src\crypto; ..\..\..\component\common\application\amazon\amazon-freertos\lib\include\private; ..\..\..\component\common\ui\emwin\emWinLibrary\include; ..\..\..\component\common\ui\emwin\Sample\rtl8721d\Config; ..\..\..\component\common\ui\emwin\Sample\rtl8721d\hal; ..\..\..\component\common\ui\emwin\Third_Party\truetype; ..\..\..\component\common\network\libcoap\include; ..\..\..\component\common\bluetooth\realtek\sdk; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebad\lib; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebad\src; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebad\src\hci; ..\..\..\component\common\bluetooth\realtek\sdk\board\amebad\src\vendor_cmd; ..\..\..\component\common\bluetooth\realtek\sdk\board\common\inc; ..\..\..\component\common\bluetooth\realtek\sdk\example\ble_central; ..\..\..\component\common\bluetooth\realtek\sdk\example\ble_peripheral; ..\..\..\component\common\bluetooth\realtek\sdk\example\ble_scatternet; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_airsync_config; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_beacon; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_breeze; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_config; ..\..\..\component\common\bluetooth\realtek\sdk\inc; ..\..\..\component\common\bluetooth\realtek\sdk\inc\app; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\gap; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\client; ..\..\..\component\common\bluetooth\realtek\sdk\inc\bluetooth\profile\server; ..\..\..\component\common\bluetooth\realtek\sdk\inc\os; ..\..\..\component\common\bluetooth\realtek\sdk\inc\platform; ..\..\..\component\common\bluetooth\realtek\sdk\inc\stack; ..\..\..\component\common\bluetooth\realtek\sdk\src\mcu\module\data_uart_cmd; ..\..\..\component\common\application\airsync\1.0.4; ..\..\..\component\common\application\breeze\api; ..\..\..\component\common\application\breeze\core\include; ..\..\..\component\common\application\breeze\include; ..\..\..\component\common\application\breeze\ref-impl; ..\..\..\component\common\network\ssl\mbedtls-3.2.1\include\mbedtls; ..\..\..\component\common\network\ssl\mbedtls-3.2.1\library; ..\..\..\component\common\file_system\dct; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\api; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\api\device; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\api\provisioner; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\device; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\cmd; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\common; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\gap; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\inc; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\inc\amebaz2; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\model; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\model\realtek; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\platform; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\lib\profile; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh\provisioner; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_device_rtk_demo; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_multiple_profile\device_multiple_profile; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_multiple_profile\provisioner_multiple_profile; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_provisioner_rtk_demo; ..\..\..\component\common\bluetooth\realtek\sdk\example\bt_mesh_provisioner_rtk_demo\inc; ..\..\..\component\common\media\mmfv2; ..\..\..\component\common\media\rtp_codec
  AARM.ADefines: CONFIG_PLATFORM_8721D; __FPU_PRESENT; CONFIG_USE_MBEDTLS_ROM_ALG; CONFIG_FUNCION_O0_OPTIMIZE; DM_ODM_SUPPORT_TYPE=32; CONFIG_TRUSTZONE_EN=1
  ILINK.IlinkIcfFile: rtl8721dhp_image2_tz.icf
configuration tz (mp) (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CONFIG_PLATFORM_8721D; __FPU_PRESENT; CONFIG_USE_MBEDTLS_ROM_ALG; CONFIG_FUNCION_O0_OPTIMIZE; DM_ODM_SUPPORT_TYPE=32; CONFIG_TRUSTZONE_EN=1; CONFIG_BUILD_NONSECURE=1; CONFIG_MP_INCLUDED; CONFIG_BT_MP
  ICCARM.CCIncludePath2: as above
  AARM.ADefines: CONFIG_PLATFORM_8721D; __FPU_PRESENT; CONFIG_USE_MBEDTLS_ROM_ALG; CONFIG_FUNCION_O0_OPTIMIZE; DM_ODM_SUPPORT_TYPE=32; CONFIG_TRUSTZONE_EN=1; CONFIG_MP_INCLUDED; CONFIG_BT_MP
  postbuild: as above
  ILINK.IlinkIcfFile: rtl8721dhp_image2_tz.icf
  group @SRAM/network/lwip/port
    ../../../component/common/network/lwip/lwip_v2.0.2/port/realtek/freertos/: br_rpt_handle.c bridgeif.c bridgeif_fdb.c ethernetif.c sys_arch.c
    ../../../component/common/drivers/wlan/realtek/src/osdep/: lwip_intf.c
  group @SRAM/network/lwip/src/api
    ../../../component/common/network/lwip/lwip_v2.0.2/src/api/: api_lib.c api_msg.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group @SRAM/network/lwip/src/core
    ../../../component/common/network/lwip/lwip_v2.0.2/src/core/: def.c inet_chksum.c ip.c mem.c memp.c netif.c pbuf.c raw.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../component/common/network/lwip/lwip_v2.0.2/src/core/ipv4/: etharp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../component/common/network/lwip/lwip_v2.0.2/src/core/ipv6/: ethip6.c ip6.c ip6_addr.c ip6_frag.c
  group @SRAM/network/lwip/src/netif
    ../../../component/common/network/lwip/lwip_v2.0.2/src/netif/: ethernet.c
  group @SRAM/os/freertos
    ../../../component/os/freertos/: cmsis_os.c freertos_backtrace_ext.c freertos_cb.c freertos_heap5_config.c freertos_service.c
  group @SRAM/os/freertos/source
    ../../../component/os/freertos/freertos_v10.2.0/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../component/os/freertos/freertos_v10.2.0/Source/portable/MemMang/: heap_5.c
  group @SRAM/os/freertos/source/portable
    ../../../component/os/freertos/freertos_v10.2.0/Source/portable/IAR/RTL8721D_HP/non_secure/: port.c portasm.s
  group @SRAM/os/os_dep
    ../../../component/os/os_dep/: device_lock.c osdep_service.c psram_reserve.c
  group app
    ../../../component/soc/realtek/amebad/app/touch_key/: touch_key.c
  group app/monitor
    ../../../component/soc/realtek/amebad/app/monitor/ram/: low_level_io.c monitor_hp.c rtl_trace.c shell_ram.c
    ../../../component/soc/realtek/amebad/app/monitor/rom/: monitor_rom.c shell_rom.c
  group application/emwin/emWinLibrary
    ../../../component/common/ui/emwin/emWinLibrary/GUI_X/: GUI_X_FreeRTOS.c GUI_X_Touch_Analog.c
    ../../../component/common/ui/emwin/emWinLibrary/lib/rtl8721d/: lib_emwin.a
  group application/emwin/Sample
    ../../../component/common/ui/emwin/Sample/rtl8721d/hal/: gt911.c hal_rgb_lcd.c hal_touch.c
    ../../../component/common/ui/emwin/Sample/rtl8721d/Config/: GUIConf.c LCDConf_RGB_6bit_eval.c
  group application/emwin/Third_Party/truetype
    ../../../component/common/ui/emwin/Third_Party/truetype/: autofit.c bdf.c cff.c ftbase.c ftbbox.c ftbdf.c ftbitmap.c ftbzip2.c ftcache.c ftcid.c ftdebug.c ftfstype.c ftgasp.c ftglyph.c ftgxval.c ftgzip.c ftinit.c ftlcdfil.c ftlzw.c ftmm.c ftotval.c ftpatent.c ftpfr.c ftstroke.c ftsynth.c ftsystem.c fttype1.c ftwinfnt.c ftxf86.c GUI_TTF.c gxvalid.c otvalid.c pcf.c pfr.c psaux.c pshinter.c psnames.c raster.c sfnt.c smooth.c truetype.c type1.c type1cid.c type42.c winfnt.c
  group application/mqtt
    ../../../component/common/application/mqtt/MQTTClient/: MQTTClient.c MQTTFreertos.c
    ../../../component/common/application/mqtt/MQTTPacket/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group audio
    ../../../component/common/audio/resample/: resample_48khz.c resample_by_2_internal.c resample_fractional.c
  group bluetooth
    ../../../component/common/bluetooth/realtek/sdk/: bt_example_entry.c
  group bluetooth/board/amebad/src
    ../../../component/common/bluetooth/realtek/sdk/board/amebad/src/: platform_utils.c rtk_coex.c trace_uart.c
  group bluetooth/board/amebad/src/data_uart
    ../../../component/common/bluetooth/realtek/sdk/board/amebad/src/data_uart/: data_uart.c
  group bluetooth/board/amebad/src/hci
    ../../../component/common/bluetooth/realtek/sdk/board/amebad/src/hci/: bt_fwconfig.c bt_mp_patch.c bt_normal_patch.c hci_board.c hci_uart.c
  group bluetooth/board/amebad/src/vendor_cmd
    ../../../component/common/bluetooth/realtek/sdk/board/amebad/src/vendor_cmd/: vendor_cmd.c
  group bluetooth/board/common/os
    ../../../component/common/bluetooth/realtek/sdk/board/common/os/freertos/: osif_freertos.c
  group bluetooth/board/common/src
    ../../../component/common/bluetooth/realtek/sdk/board/common/src/: bt_uart_bridge.c cycle_queue.c hci_adapter.c hci_process.c trace_task.c
  group bluetooth/example/ble_central
    ../../../component/common/bluetooth/realtek/sdk/example/ble_central/: ble_central_app_main.c ble_central_app_task.c ble_central_at_cmd.c ble_central_client_app.c ble_central_link_mgr.c user_cmd.c
  group bluetooth/example/ble_peripheral
    ../../../component/common/bluetooth/realtek/sdk/example/ble_peripheral/: app_task.c ble_app_main.c ble_peripheral_at_cmd.c peripheral_app.c
  group bluetooth/example/ble_scatternet
    ../../../component/common/bluetooth/realtek/sdk/example/ble_scatternet/: ble_scatternet_app.c ble_scatternet_app_main.c ble_scatternet_app_task.c ble_scatternet_link_mgr.c ble_scatternet_user_cmd.c
  group bluetooth/example/bt_airsync_config
    ../../../component/common/application/airsync/1.0.4/: airsync_ble_service.c check_endian.c epb.c epb_MmBp.c epb_WristBand.c wechat_airsync_protocol.c
    ../../../component/common/bluetooth/realtek/sdk/example/bt_airsync_config/: bt_airsync_config_app_main.c bt_airsync_config_app_task.c bt_airsync_config_peripheral_app.c
  group bluetooth/example/bt_ancs
    ../../../component/common/bluetooth/realtek/sdk/example/bt_ancs/: bt_ancs.c bt_ancs_app.c bt_ancs_app_task.c bt_ancs_main.c
  group bluetooth/example/bt_beacon
    ../../../component/common/bluetooth/realtek/sdk/example/bt_beacon/: bt_beacon_app.c bt_beacon_app_main.c bt_beacon_app_task.c
  group bluetooth/example/bt_breeze
    ../../../component/common/application/breeze/ref-impl/: aes.c sha256.c
    ../../../component/common/application/breeze/core/src/: auth.c ble_service.c core.c extcmd.c transport.c utils.c
    ../../../component/common/bluetooth/realtek/sdk/example/bt_breeze/: breeze.c bt_breeze_app_main.c bt_breeze_app_task.c bt_breeze_peripheral_app.c
    ../../../component/common/application/breeze/api/: breeze_awss_export.c breeze_export.c
    ../../../component/common/bluetooth/realtek/sdk/example/bt_breeze/hal/: breeze_hal_ble.c breeze_hal_os.c breeze_hal_sec.c
  group bluetooth/example/bt_config
    ../../../component/common/bluetooth/realtek/sdk/example/bt_config/: bt_config_app_main.c bt_config_app_task.c bt_config_peripheral_app.c bt_config_service.c bt_config_wifi.c
  group bluetooth/example/bt_distance_detector
    ../../../component/common/bluetooth/realtek/sdk/example/bt_distance_detector/: bt_distance_detector_app.c bt_distance_detector_app_task.c bt_distance_detector_handle_message.c bt_distance_detector_main.c bt_distance_detector_mode.c
  group bluetooth/example/bt_mesh/mesh_common/cmd
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/cmd/: mesh_cmd.c mesh_data_uart.c mesh_user_cmd_parse.c test_cmd.c
  group bluetooth/example/bt_mesh/mesh_common/common
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/api/: bt_mesh_user_api.c
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/common/: customer_dfu_service.c datatrans_app.c dfudep_service.c ping_app.c
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/model/: delay_msg_rsp.c
  group bluetooth/example/bt_mesh/mesh_common/model
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/model/realtek/: datatrans_model.c ping_control.c tp_control.c
  group bluetooth/example/bt_mesh/mesh_common/profile
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/profile/: datatrans_service.c
  group bluetooth/example/bt_mesh/mesh_device
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/api/device/: bt_mesh_device_api.c
  group bluetooth/example/bt_mesh/mesh_device/bt_mesh_device_rtk_demo
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh_device_rtk_demo/: example_bt_mesh_device_rtk_demo.c
  group bluetooth/example/bt_mesh/mesh_device/common
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/api/device/: device_idle_check.c
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/common/: dfu_updater_app.c light_server_app.c scene_server_app.c scheduler_server_app.c time_server_app.c
  group bluetooth/example/bt_mesh/mesh_device/device
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/device/: bt_mesh_device_app_main.c bt_mesh_device_app_task.c device_app.c device_cmd.c
  group bluetooth/example/bt_mesh/mesh_device/device_multiple_profile
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh_multiple_profile/device_multiple_profile/: bt_mesh_device_multiple_profile_app_main.c bt_mesh_device_multiple_profile_app_task.c device_multiple_profile_app.c device_multiple_profile_cmd.c
  group bluetooth/example/bt_mesh/mesh_device/lib
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/lib/amebad/: btmesh_dev.a
  group bluetooth/example/bt_mesh/mesh_device/model
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/model/: delay_execution.c generic_on_off_server.c generic_transition_time.c health_server.c light_ctl_server.c light_ctl_setup_server.c light_ctl_temperature_server.c light_hsl_hue_server.c light_hsl_saturation_server.c light_hsl_server.c light_hsl_setup_server.c light_lightness_server.c light_lightness_setup_server.c light_xyl_server.c light_xyl_setup_server.c scene_server.c scene_setup_server.c scheduler_server.c scheduler_setup_server.c time_server.c time_setup_server.c
  group bluetooth/example/bt_mesh/mesh_device/profile
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/profile/: datatrans_server.c
  group bluetooth/example/bt_mesh/mesh_provisioner
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/api/provisioner/: bt_mesh_provisioner_api.c
  group bluetooth/example/bt_mesh/mesh_provisioner/bt_mesh_provisioner_rtk_demo
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh_provisioner_rtk_demo/src/: bt_mesh_app_http_intf.c bt_mesh_app_lib_intf.c bt_mesh_app_list_intf.c bt_mesh_broadcast_demo.c
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh_provisioner_rtk_demo/: example_bt_mesh_provisioner_rtk_demo.c
  group bluetooth/example/bt_mesh/mesh_provisioner/cmd
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/cmd/: client_cmd.c
  group bluetooth/example/bt_mesh/mesh_provisioner/common
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/common/: dfu_distributor_app.c generic_client_app.c light_client_app.c rmt_prov_client_app.c
  group bluetooth/example/bt_mesh/mesh_provisioner/lib
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/lib/amebad/: btmesh_prov.a
  group bluetooth/example/bt_mesh/mesh_provisioner/model
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/model/: blob_transfer_client.c configuration_client.c firmware_distribution_client.c firmware_update_client.c generic_battery_client.c generic_default_transition_time_client.c generic_level_client.c generic_location_client.c generic_on_off_client.c generic_power_level_client.c generic_power_on_off_client.c generic_property_client.c health_client.c light_ctl_client.c light_hsl_client.c light_lc_client.c light_lightness_client.c light_xyl_client.c private_beacon_client.c scene_client.c scheduler_client.c sensor_client.c time_client.c
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/lib/model/realtek/: light_cwrgb_client.c
  group bluetooth/example/bt_mesh/mesh_provisioner/provisioner
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh/provisioner/: bt_mesh_provisioner_app_main.c bt_mesh_provisioner_app_task.c provisioner_app.c provisioner_cmd.c
  group bluetooth/example/bt_mesh/mesh_provisioner/provisioner_multiple_profile
    ../../../component/common/bluetooth/realtek/sdk/example/bt_mesh_multiple_profile/provisioner_multiple_profile/: bt_mesh_provisioner_multiple_profile_app_main.c bt_mesh_provisioner_multiple_profile_app_task.c provisioner_multiple_profile_app.c provisioner_multiple_profile_cmd.c
  group bluetooth/example/bt_tag_scanner
    ../../../component/common/bluetooth/realtek/sdk/example/bt_tag_scanner/: bt_tag_scanner_app.c bt_tag_scanner_app_task.c bt_tag_scanner_keep_message.c bt_tag_scanner_main.c
  group bluetooth/src/ble/profile/client
    ../../../component/common/bluetooth/realtek/sdk/src/ble/profile/client/: ancs_client.c gcs_client.c
    ../../../component/common/bluetooth/realtek/sdk/src/ble/profile/server/: bas.c simple_ble_service.c
  group bluetooth/src/mcu/module/data_uart_cmd
    ../../../component/common/bluetooth/realtek/sdk/src/mcu/module/data_uart_cmd/: user_cmd_parse.c
  group cmsis-dsp
    ../../../component/soc/realtek/amebad/cmsis-dsp/Source/BasicMathFunctions/: arm_abs_f32.c arm_abs_q15.c arm_abs_q31.c arm_abs_q7.c arm_add_f32.c arm_add_q15.c arm_add_q31.c arm_add_q7.c arm_dot_prod_f32.c arm_dot_prod_q15.c arm_dot_prod_q31.c arm_dot_prod_q7.c arm_mult_f32.c arm_mult_q15.c arm_mult_q31.c arm_mult_q7.c arm_negate_f32.c arm_negate_q15.c arm_negate_q31.c arm_negate_q7.c arm_offset_f32.c arm_offset_q15.c arm_offset_q31.c arm_offset_q7.c arm_scale_f32.c arm_scale_q15.c arm_scale_q31.c arm_scale_q7.c arm_shift_q15.c arm_shift_q31.c arm_shift_q7.c arm_sub_f32.c arm_sub_q15.c arm_sub_q31.c arm_sub_q7.c
    ../../../component/soc/realtek/amebad/cmsis-dsp/Source/TransformFunctions/: arm_bitreversal.c arm_bitreversal2.S arm_cfft_f32.c arm_cfft_q15.c arm_cfft_q31.c arm_cfft_radix2_f32.c arm_cfft_radix2_init_f32.c arm_cfft_radix2_init_q15.c arm_cfft_radix2_init_q31.c arm_cfft_radix2_q15.c arm_cfft_radix2_q31.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c arm_cfft_radix4_init_q15.c arm_cfft_radix4_init_q31.c arm_cfft_radix4_q15.c arm_cfft_radix4_q31.c arm_cfft_radix8_f32.c arm_dct4_f32.c arm_dct4_init_f32.c arm_dct4_init_q15.c arm_dct4_init_q31.c arm_dct4_q15.c arm_dct4_q31.c arm_rfft_f32.c arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c arm_rfft_init_f32.c arm_rfft_init_q15.c arm_rfft_init_q31.c
    ../../../component/soc/realtek/amebad/cmsis-dsp/Source/ComplexMathFunctions/: arm_cmplx_conj_f32.c arm_cmplx_conj_q15.c arm_cmplx_conj_q31.c arm_cmplx_dot_prod_f32.c arm_cmplx_dot_prod_q15.c arm_cmplx_dot_prod_q31.c arm_cmplx_mag_f32.c arm_cmplx_mag_q15.c arm_cmplx_mag_q31.c arm_cmplx_mag_squared_f32.c arm_cmplx_mag_squared_q15.c arm_cmplx_mag_squared_q31.c arm_cmplx_mult_cmplx_f32.c arm_cmplx_mult_cmplx_q15.c arm_cmplx_mult_cmplx_q31.c arm_cmplx_mult_real_f32.c arm_cmplx_mult_real_q15.c arm_cmplx_mult_real_q31.c
    ../../../component/soc/realtek/amebad/cmsis-dsp/Source/CommonTables/: arm_common_tables.c arm_const_structs.c
    ../../../component/soc/realtek/amebad/cmsis-dsp/Source/FastMathFunctions/: arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_sin_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c
  group drivers/ir
    ../../../component/common/drivers/ir/protocol/: ir_led.c ir_nec_protocol.c
  group drivers/si
    ../../../component/common/drivers/si/: rl6548.c
  group drivers/usb_class/device/audio
    ../../../component/common/drivers/usb/device/audio/src/: usb_f_uac1.c
  group drivers/usb_class/device/cdc_acm
    ../../../component/common/drivers/usb/device/cdc_acm/src/: usbd_cdc_acm.c
  group drivers/usb_class/device/hid
    ../../../component/common/drivers/usb/device/hid/src/: usbd_hid.c
  group drivers/usb_class/device/msc
    ../../../component/common/drivers/usb/device/msc/src/: usbd_msc.c usbd_scsi.c
  group drivers/usb_class/device/vendor
    ../../../component/common/drivers/usb/device/vendor/src/: usbd_vendor.c usbd_vendor_desc.c
  group drivers/usb_class/host/cdc_acm
    ../../../component/common/drivers/usb/host/cdc_acm/src/: usbh_cdc_acm.c
  group drivers/usb_class/host/msc
    ../../../component/common/drivers/usb/host/msc/src/scsi/: scsi_eh.c
    ../../../component/common/drivers/usb/host/msc/src/: us.c us_debug.c us_initializers.c us_intf.c us_protocol.c us_scsi.c us_transport.c usual_tables.c
  group drivers/usb_class/host/uvc
    ../../../component/common/drivers/usb/host/uvc/src/: uvc_ctrl.c uvc_driver.c uvc_intf.c uvc_queue.c uvc_status.c uvc_v4l2.c uvc_video.c
  group drivers/usb_class/host/vendor
    ../../../component/common/drivers/usb/host/vendor/src/: usbh_vendor.c
  group fwlib
    ../../../component/soc/realtek/amebad/fwlib/ram_common/: rtl8721d_adc.c rtl8721d_bor.c rtl8721d_captouch.c rtl8721d_comparator.c rtl8721d_flash_ram.c rtl8721d_gdma_memcpy.c rtl8721d_i2c.c rtl8721d_ipc_api.c rtl8721d_ir.c rtl8721d_keyscan.c rtl8721d_pll.c rtl8721d_ram_libc.c rtl8721d_rtc.c rtl8721d_sgpio.c rtl8721d_tim.c rtl8721d_uart.c rtl8721d_wdg.c
    ../../../component/soc/realtek/amebad/fwlib/crypto/: rtl8721dhp_aes_ram.c rtl8721dhp_chacha_poly1305.c rtl8721dhp_crypto_ram.c rtl8721dhp_des_ram.c rtl8721dhp_md5.c rtl8721dhp_sha.c
    ../../../component/soc/realtek/amebad/fwlib/ram_hp/: rtl8721dhp_app_start.c rtl8721dhp_audio.c rtl8721dhp_clk.c rtl8721dhp_cpft.c rtl8721dhp_i2s.c rtl8721dhp_lcdc.c rtl8721dhp_ota_ram.c rtl8721dhp_sd.c rtl8721dhp_sdio.c rtl8721dhp_sdio_host.c rtl8721dhp_simulation.c rtl8721dhp_ssi.c rtl8721dhp_startup.c rtl8721dhp_system.c rtl8721dhp_usi_i2c.c rtl8721dhp_usi_ssi.c rtl8721dhp_usi_uart.c
  group fwlib/usrcfg
    ../../../component/soc/realtek/amebad/fwlib/usrcfg/: rtl8721d_ipccfg.c rtl8721d_wificfg.c rtl8721dhp_intfcfg.c rtl8721dlp_intfcfg.c
  group lib
    ../../../component/common/bluetooth/realtek/sdk/board/amebad/lib/: btgap.a
    ../../../component/soc/realtek/amebad/misc/bsp/lib/common/IAR/: cmse_implib.a cmse_implib_mp.a lib_ac3.a lib_amr.a lib_coap.a lib_dct.a lib_eap.a lib_ekho.a lib_gsm610.a lib_haac.a lib_hmp3.a lib_httpc.a lib_httpd.a lib_libogg.a lib_mdns.a lib_mmfv2.a lib_mp3.a lib_opus.a lib_opusenc.a lib_opusfile.a lib_pmc_hp.a lib_rtp_codec.a lib_rtsp.a lib_tftp.a lib_usbd.a lib_usbh.a lib_v4l2.a lib_websocket.a lib_wlan.a lib_wlan_mp.a lib_wps.a
  group mbed
    ../../../component/common/mbed/targets/hal/rtl8721d/: analogin_api.c dma_api.c efuse_api.c flash_api.c gpio_api.c gpio_irq_api.c i2c_api.c i2s_api.c pinmap.c pinmap_common.c port_api.c pwmout_api.c rtc_api.c serial_api.c sleep.c spdio_api.c spi_api.c sys_api.c timer_api.c us_ticker.c us_ticker_api.c wait_api.c wdt_api.c
  group misc
    ../../../component/soc/realtek/amebad/misc/: rtl8721d_ota.c
  group user
    ../src/src_hp/: main.c
  group utilities
    ../../../component/common/utilities/: cJSON.c http_client.c ssl_client.c ssl_client_ext.c ssl_client_ext_ns.c ssl_client_ns.c tcptest.c webserver.c xml.c
  group utilities/example
    ../../../component/common/example/audio_sport/audio_ac3/: a52dec.c example_audio_ac3.c
    ../../../component/common/example/audio_sport/audio_opus_encode/: audio_opus_encode.c
    ../../../component/common/example/audio_sport/audio_amr_flash/: audio_play.c example_audio_amr_flash.c
    ../../../component/common/example/amazon_freertos/: example_amazon_freertos.c
    ../../../component/common/example/audio_sport/audio_amr/: example_audio_amr.c
    ../../../component/common/example/audio_sport/audio_ekho/: example_audio_ekho.c
    ../../../component/common/example/audio_sport/audio_helix_aac/: example_audio_helix_aac.c
    ../../../component/common/example/audio_sport/audio_helix_mp3/: example_audio_helix_mp3.c
    ../../../component/common/example/audio_sport/audio_mp3/: example_audio_mp3.c
    ../../../component/common/example/audio_sport/audio_opus_decode/: example_audio_opus_decode.c Psram_realloc.c
    ../../../component/common/example/audio_sport/audio_recorder/: example_audio_recorder_iar.c
    ../../../component/common/example/audio_sport/audio_signal_generate/: example_audio_signal_generate.c
    ../../../component/common/example/bcast/: example_bcast.c
    ../../../component/common/example/cJSON/: example_cJSON.c
    ../../../component/common/example/cm_backtrace/: example_cm_backtrace.c
    ../../../component/common/example/coap/: example_coap.c
    ../../../component/common/example/coap_client/: example_coap_client.c
    ../../../component/common/example/coap_server/: example_coap_server.c
    ../../../component/common/example/eap/: example_eap.c
    ../../../component/common/example/: example_entry.c
    ../../../component/common/example/fatfs/: example_fatfs.c
    ../../../component/common/example/get_beacon_frame/: example_get_beacon_frame.c
    ../../../component/common/example/high_load_memory_use/: example_high_load_memory_use.c
    ../../../component/common/example/http_client/: example_http_client.c
    ../../../component/common/example/http_download/: example_http_download.c
    ../../../component/common/example/httpc/: example_httpc.c
    ../../../component/common/example/httpd/: example_httpd.c
    ../../../component/common/example/mcast/: example_mcast.c
    ../../../component/common/example/mdns/: example_mdns.c
    ../../../component/common/example/mqtt/: example_mqtt.c
    ../../../component/common/example/nonblock_connect/: example_nonblock_connect.c
    ../../../component/common/example/ota_http/: example_ota_http.c
    ../../../component/common/example/ota_https/: example_ota_https.c
    ../../../component/common/example/ota_sdcard/: example_ota_sdcard.c
    ../../../component/common/example/rarp/: example_rarp.c
    ../../../component/common/example/sdcard_upload_httpd/: example_sdcard_upload_httpd.c
    ../../../component/common/example/sntp_showtime/: example_sntp_showtime.c
    ../../../component/common/example/socket_select/: example_socket_select.c
    ../../../component/common/example/socket_tcp_trx/: example_socket_tcp_trx_1.c example_socket_tcp_trx_2.c
    ../../../component/common/example/ssl_download/: example_ssl_download.c
    ../../../component/common/example/ssl_server/: example_ssl_server.c
    ../../../component/common/example/tcp_keepalive/: example_tcp_keepalive.c
    ../../../component/common/example/uart_atcmd/: example_uart_atcmd.c
    ../../../component/common/example/wifi_mac_monitor/: example_wifi_mac_monitor.c
    ../../../component/common/example/wifi_manager/: example_wifi_manager.c
    ../../../component/common/example/wifi_roaming/: example_wifi_roaming.c
    ../../../component/common/example/wlan_fast_connect/: example_wlan_fast_connect.c
    ../../../component/common/example/wlan_repeater/: example_wlan_repeater.c
    ../../../component/common/example/wlan_scenario/: example_wlan_scenario.c
    ../../../component/common/example/websocket_server/: example_ws_server.c
    ../../../component/common/example/websocket_client/: example_wsclient.c
    ../../../component/common/example/xml/: example_xml.c
  group utilities/example/example_uart_update
    ../../../component/common/example/uart_firmware_update/: example_uart_update.c
    ../../../component/common/application/xmodem/: uart_fw_update.c xmodem.c
  group utilities/example/usb_example/device
    ../../../component/common/example/usbd_audio/: example_usbd_audio.c example_usbd_audio_sp.c
    ../../../component/common/example/usbd_cdc_acm/: example_usbd_cdc_acm.c
    ../../../component/common/example/usbd_hid_mouse/: example_usbd_hid_mouse.c
    ../../../component/common/example/usbd_msc/: example_usbd_msc.c
    ../../../component/common/example/usbd_vendor/: example_usbd_vendor.c
  group utilities/example/usb_example/host
    ../../../component/common/example/usbh_cdc_acm/: example_usbh_cdc_acm.c
    ../../../component/common/example/usbh_msc/: example_usbh_msc.c
    ../../../component/common/example/usbh_uvc/: example_usbh_uvc.c
    ../../../component/common/example/usbh_vendor/: example_usbh_vendor.c
  group utilities/fatfs
    ../../../component/common/file_system/fatfs/r0.10c/src/option/: ccsbcs.c
    ../../../component/common/file_system/fatfs/r0.10c/src/: diskio.c ff.c
    ../../../component/common/file_system/fatfs/fatfs_ext/src/: ff_driver.c
    ../../../component/common/file_system/fatfs/disk_if/src/: flash_fatfs.c sdcard.c usbdisk.c
  group utilities/ftl
    ../../../component/common/file_system/ftl/: ftl.c
  group wifi/api
    ../../../component/common/api/at_cmd/: atcmd_bt.c atcmd_lwip.c atcmd_mp.c atcmd_mp_ext0.c atcmd_mp_ext1.c atcmd_mp_ext2.c atcmd_sys.c atcmd_wifi.c log_service.c
    ../../../component/common/api/: lwip_netconf.c wifi_interactive_mode.c
    ../../../component/common/api/network/src/: ping_test.c ttcp.c wlan_network.c
    ../../../component/common/api/wifi/rtw_wpa_supplicant/src/crypto/: tls_polarssl.c
    ../../../component/common/api/wifi/: wifi_conf.c wifi_ind.c wifi_promisc.c wifi_simple_config.c wifi_util.c
    ../../../component/common/api/wifi/rtw_wpa_supplicant/wpa_supplicant/: wifi_eap_config.c wifi_p2p_config.c wifi_wps_config.c
  group wifi/network
    ../../../component/common/network/dhcp/: dhcps.c
    ../../../component/common/network/httpc/: httpc_tls.c
    ../../../component/common/network/httpd/: httpd_tls.c
    ../../../component/common/network/sntp/: sntp.c
    ../../../component/common/network/websocket/: wsclient_tls.c wsserver_tls.c
  group wifi/network/coap_ns
    ../../../component/common/network/coap/: sn_coap_ameba_port.c sn_coap_builder.c sn_coap_header_check.c sn_coap_parser.c sn_coap_protocol.c
  group wifi/network/lwip/api
    ../../../component/common/network/lwip/lwip_v2.0.2/src/api/: err.c
  group wifi/network/lwip/core
    ../../../component/common/network/lwip/lwip_v2.0.2/src/core/ipv4/: autoip.c dhcp.c icmp.c
    ../../../component/common/network/lwip/lwip_v2.0.2/src/core/ipv6/: dhcp6.c icmp6.c inet6.c mld6.c nd6.c
    ../../../component/common/network/lwip/lwip_v2.0.2/src/core/: dns.c init.c stats.c sys.c
  group wifi/network/mDNS
    ../../../component/common/network/mDNS/: mDNSPlatform.c
  group wifi/network/ssl/library
    ../../../component/common/network/ssl/mbedtls-3.2.1/library/: aes.c aesni.c aria.c asn1parse.c asn1write.c base64.c bignum.c camellia.c ccm.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c constant_time.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c hmac_drbg.c md.c md5.c memory_buffer_alloc.c mps_reader.c mps_trace.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers.c psa_crypto_ecp.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c ripemd160.c rsa.c rsa_alt_helpers.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_debug_helpers_generated.c ssl_msg.c ssl_ticket.c ssl_tls.c ssl_tls12_client.c ssl_tls12_server.c ssl_tls13_client.c ssl_tls13_generic.c ssl_tls13_keys.c ssl_tls13_server.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c
    ../../../component/common/network/ssl/ssl_ram_map/: ssl_ram_map.c
  group wifi/network/ssl/ssl_wrapper
    ../../../component/common/network/ssl/ssl_wrapper/: ssl_wrapper.c
