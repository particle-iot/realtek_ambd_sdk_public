# IAR project km0_application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: CONFIG_PLATFORM_8721D; __ARM_FEATURE_DSP=0
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\component\soc\realtek\amebad\fwlib\include; ..\inc\inc_lp; ..\..\..\component\soc\realtek\amebad\swlib\string; ..\..\..\component\soc\realtek\amebad\swlib\include; ..\..\..\component\soc\realtek\amebad\app\monitor\include; ..\..\..\component\soc\realtek\amebad\app\touch_key; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\include; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_LP; ..\..\..\component\soc\realtek\amebad\cmsis; ..\..\..\component\soc\realtek\amebad\wifi_fw\include; ..\..\..\component\soc\realtek\amebad\app\monitor\include; ..\..\..\component\soc\realtek\amebad\app\xmodem; ..\..\..\component\soc\realtek\amebad\swlib\include; ..\..\..\component\soc\realtek\amebad\swlib\string; ..\..\..\component\soc\realtek\amebad\misc; ..\..\..\component\common\api; ..\..\..\component\common\api\wifi; ..\..\..\component\common\api\network; ..\..\..\component\common\api\network\include; ..\..\..\component\common\test; ..\..\..\component\common\example; ..\..\..\component\common\utilities; ..\..\..\component\common\drivers\wlan\realtek\include; ..\..\..\component\common\drivers\wlan\realtek\src\hci; ..\..\..\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\component\common\drivers\wlan\realtek\src\hal; ..\..\..\component\common\drivers\wlan\realtek\src\hal\OUTSRC; ..\..\..\component\common\drivers\wlan\realtek\src\hal\rtl8721d; ..\..\..\component\common\drivers\wlan\realtek\wlan_ram_map\rom; ..\..\..\component\common\network; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include\lwip; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include\netif; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek\freertos; ..\..\..\component\common\api; ..\..\..\component\common\api\at_cmd; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\component\os\os_dep\include\; ..\..\..\component\common\network\ssl\polarssl-1.3.8\include; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\common\network\ssl\mbedtls-2.4.0\include; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\common\mbed\targets\hal\rtl8721d\; ..\..\..\component\common\application\apple\WACServer\External\Curve25519; ..\..\..\component\common\application\apple\WACServer\External\GladmanAES; ..\..\..\component\common\application\apple\homekit\crypto\chacha; ..\..\..\component\common\application\apple\homekit\crypto\poly1305; ..\..\..\component\common\application\apple\homekit\crypto\ed25519; ..\..\..\component\common\application\apple\homekit\crypto\ed25519\core; ..\..\..\component\common\application\apple\homekit\crypto\sha512; ..\..\..\component\common\api\platform; ..\..\..\component\common\application\amazon\amazon-freertos\lib\include\private
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc\inc_lp; ..\..\..\component\os\freertos\freertos_v10.2.0\Source\portable\IAR\RTL8721D_LP
  OBJCOPY.OOCOutputFile: km0_application.srec
  prebuild: CSCRIPT  "..\..\..\component\soc\realtek\amebad\misc\iar_utility\common\rtl8721d_prebuild.vbs" "$PROJ_DIR$" "..\inc\inc_lp"
  postbuild: CSCRIPT  "..\..\..\component\soc\realtek\amebad\misc\iar_utility\common\rtl8721dlp_postbuild_img2.vbs" "$TARGET_DIR$" "$PROJ_DIR$" "$TOOLKIT_DIR$"
  ILINK.IlinkOutputFile: km0_application.axf
  ILINK.IlinkIcfFile: rtl8721dlp_image2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group app
    ../../../component/soc/realtek/amebad/app/touch_key/: touch_key.c
  group console
    ../../../component/soc/realtek/amebad/app/monitor/ram/: monitor_lp.c rtl_trace.c shell_ram.c
  group fwlib
    ../../../component/soc/realtek/amebad/fwlib/ram_common/: rtl8721d_adc.c rtl8721d_bor.c rtl8721d_captouch.c rtl8721d_comparator.c rtl8721d_efuse.c rtl8721d_flash_ram.c rtl8721d_i2c.c rtl8721d_ipc_api.c rtl8721d_keyscan.c rtl8721d_pll.c rtl8721d_qdec.c rtl8721d_rtc.c rtl8721d_sgpio.c rtl8721d_tim.c rtl8721d_uart.c rtl8721d_wdg.c
    ../../../component/soc/realtek/amebad/fwlib/usrcfg/: rtl8721d_ipccfg.c rtl8721d_wificfg.c rtl8721dlp_flashcfg.c rtl8721dlp_intfcfg.c rtl8721dlp_pinmapcfg.c rtl8721dlp_sleepcfg.c
    ../../../component/soc/realtek/amebad/fwlib/ram_lp/: rtl8721dlp_app_start.c rtl8721dlp_clk.c rtl8721dlp_cpft.c rtl8721dlp_flashclk.c rtl8721dlp_km4.c rtl8721dlp_pinmap.c rtl8721dlp_pmc.c rtl8721dlp_pmc_ram.c rtl8721dlp_simulation.c rtl8721dlp_startup.c rtl8721dlp_system.c
  group lib
    ../../../component/soc/realtek/amebad/misc/bsp/lib/common/IAR/: lib_wifi_fw.a
  group misc
    ../../../component/soc/realtek/amebad/misc/: rtl8721d_freertos_pmu.c
  group os/freertos
    ../../../component/os/freertos/: freertos_backtrace_ext.c freertos_heap5_config.c
  group os/freertos/source
    ../../../component/os/freertos/freertos_v10.2.0/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../component/os/freertos/freertos_v10.2.0/Source/portable/MemMang/: heap_5.c
  group os/freertos/source/portable
    ../../../component/os/freertos/freertos_v10.2.0/Source/portable/IAR/RTL8721D_LP/: port.c portasm.s
  group user
    ../src/src_lp/: main.c
